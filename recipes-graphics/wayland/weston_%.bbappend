# Copyright NXP 2019

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append = "file://0001-weston.ini-Add-Demo-Launcher-icon.patch"
