SRC_URI:remove = "http://www.qhull.org/download/qhull-2020-src-8.0.2.tgz"
SRC_URI += "git://github.com/qhull/qhull.git;protocol=https;branch=master"
SRCREV = "613debeaea72ee66626dace9ba1a2eff11b5d37d"
